<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>NN_MOD</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>data_file</value></param>
<param><key>value</key><value>data/pam4.bin</value></param>
<param><key>label0</key><value>PAM4</value></param>
<param><key>label1</key><value>BPSK</value></param>
<param><key>label2</key><value>AM-DSB</value></param>
<param><key>label3</key><value>CPFSK</value></param>
<param><key>label</key><value>Modulation Type</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>data/pam4.bin</value></param>
<param><key>option1</key><value>data/bpsk.bin</value></param>
<param><key>option2</key><value>data/am-dsb.bin</value></param>
<param><key>option3</key><value>data/cpfsk.bin</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>string</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e3</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>data_file</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>neural_networks_nn_mod_py_cf</key>
<param><key>id</key><value>neural_networks_nn_mod_py_cf_0</value></param>
<param><key>model</key><value>models/conv.json</value></param>
<param><key>weights</key><value>weights/convmodrecnets_CNN2_0.5.wts.h5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.0</value></param>
<param><key>ylabel</key><value>Modulation Type</value></param>
<param><key>yunit</key><value>8PSK</value></param>
<param><key>ymax</key><value>10</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>neural_networks_nn_mod_py_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>neural_networks_nn_mod_py_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
